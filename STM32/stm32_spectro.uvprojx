# Keil uVision project stm32_spectro.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_spectro
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./MCAL/ADC/: ADC_Config.h ADC_Interface.h ADC_Private.h ADC_Program.c
    ./MCAL/AFIO/: AFIO_Config.h AFIO_Interface.h AFIO_Private.h AFIO_Program.c
    ./MCAL/EXTI/: EXTI_Config.h EXTI_Interface.h EXTI_Private.h EXTI_Program.c
    ./MCAL/GI/: GI_Interface.h GI_Program.c
    ./MCAL/GPIO/: GPIO_Config.h GPIO_Interface.h GPIO_Private.h GPIO_Program.c
    ./MCAL/GPTMR/: GPTMR_Config.h GPTMR_Interface.h GPTMR_Private.h GPTMR_Program.c
    ./MCAL/NVIC/: NVIC_Config.h NVIC_Interface.h NVIC_Private.h NVIC_Program.c
    ./MCAL/RCC/: RCC_Config.h RCC_Interface.h RCC_Private.h RCC_Program.c
    ./MCAL/RTC/: RTC_Config.h RTC_Interface.h RTC_Private.h RTC_Program.c
    ./MCAL/SCB/: SCB_Config.h SCB_Interface.h SCB_Private.h SCB_Program.c
    ./MCAL/STK/: STK_Config.h STK_Interface.h STK_Private.h STK_Program.c
    ./MCAL/UART/: UART_Config.h UART_Interface.h UART_Private.h UART_Program.c
    ./LIB/BIT_MATH/: BIT_MATH.h
    ./LIB/STD_TYPES/: Compiler.h Platform_Types.h Std_Types.h
    ./HAL/ESP32/: ESP32_Config.h ESP32_Interface.h ESP32_Private.h ESP32_Program.c
    ./HAL/SPWRVolt/: SPWRVolt_Config.h SPWRVolt_Interface.h SPWRVolt_Program.c
    ./HAL/STEPPER_MOTOR/: MOTORS_Config.h MOTORS_Interface.h MOTORS_Private.h MOTORS_Program.c
    ./APP/SCommands/: SCommands_Config.h SCommands_Interface.h SCommands_Program.c
    ./: main.c
    ./MCAL/I2C/: I2C_Config.h I2C_Interface.h I2C_private.h I2C_Program.c
    ./MCAL/SPI/: SPI_Config.h SPI_Interface.h SPI_Private.h SPI_Program.c
    ./HAL/EEPROM/: EEPROM.c EEPROM.h
    ./HAL/ADS1115/: ADS1115.c ADS1115.h
software components: CMSIS:CORE 6.0.0, Device:Startup 1.0.0
