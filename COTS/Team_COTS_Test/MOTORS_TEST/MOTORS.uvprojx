# Keil uVision project MOTORS.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MOTORS +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: BIT_MATH.h Compiler.h GPIO_Config.h GPIO_Interface.h GPIO_Private.h GPIO_Program.c main.c Platform_Types.h RCC_Config.h RCC_Interface.h RCC_Private.h RCC_Program.c Std_Types.h STK_Config.h STK_Interface.h STK_Private.h STK_Program.c MOTORS_Config.h MOTORS_Interface.h MOTORS_Private.h MOTORS_Program.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
